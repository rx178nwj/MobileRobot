# Repository rx178nwj/MobileRobot

File README.md:

# Mobile Robot

4輪駆動移動ロボットプロジェクト - ROS 2、Python WebSocket サービス、PR2040 モータードライバを使用

## プロジェクト概要

このプロジェクトは、Raspberry Pi と PR2040 マイコンを使用した移動ロボットシステムです。ROS 2 (Jazzy) を Docker コンテナで実行し、Python ベースの Edge Services を介してハードウェアと通信します。

### 主な特徴

- **ROS 2 Jazzy** - Docker コンテナで実行（Debian 13 ホスト）
- **WebSocket 通信** - ROS 2 と Edge Services 間の通信
- **USB シリアル制御** - PR2040 モータードライバとの通信
- **リアルタイムオドメトリ** - 50Hz でのエンコーダベース位置推定
- **差動駆動制御** - 4輪駆動の差動駆動キネマティクス
- **速度制御モード** - PR2040 ファームウェアによる PID 速度制御

## システムアーキテクチャ

```
┌─────────────────────────────────────────────────────────────┐
│                    ROS 2 (Docker Container)                  │
│  ┌──────────────┐  ┌──────────────┐  ┌──────────────┐      │
│  │ ws_motor_    │  │ ws_odometry_ │  │ robot_state_ │      │
│  │ controller   │  │ publisher    │  │ publisher    │      │
│  └──────┬───────┘  └───────▲──────┘  └──────────────┘      │
└─────────┼──────────────────┼────────────────────────────────┘
          │                  │
       WebSocket          WebSocket
       (port 8001)        (port 8002)
          │                  │
          ▼                  ▼
┌─────────────────────────────────────────────────────────────┐
│                      Edge Services (Host)                    │
│  ┌──────────────┐  ┌──────────────┐  ┌──────────────┐      │
│  │ Motor        │  │ Odometry     │  │ Camera       │      │
│  │ Service      │  │ Service      │  │ Service      │      │
│  └──────┬───────┘  └───────▲──────┘  └──────────────┘      │
└─────────┼──────────────────┼────────────────────────────────┘
          │                  │
       USB Serial        USB Serial
       (/dev/ttyACM0)    (/dev/ttyACM0)
          │                  │
          ▼                  ▼
┌─────────────────────────────────────────────────────────────┐
│                  PR2040 Motor Driver                         │
│  ┌──────────┐  ┌──────────┐  ┌──────────┐  ┌──────────┐   │
│  │ Motor 0  │  │ Motor 1  │  │ Motor 2  │  │ Motor 3  │   │
│  │ (動作OK) │  │ (動作OK) │  │ (故障)   │  │ (故障)   │   │
│  └──────────┘  └──────────┘  └──────────┘  └──────────┘   │
└─────────────────────────────────────────────────────────────┘
```

## ハードウェア

- **Raspberry Pi 4** - メインコントローラ
- **PR2040 (RP2040)** - モータードライバマイコン
- **JGA25-370 モーター** - ギア比 51:1、エンコーダ付き
- **車輪**: 直径 66mm (半径 33mm)
- **ホイールベース**: 160mm

### キャリブレーション値

- **エンコーダ CPR**: 827.2 counts/revolution（キャリブレーション済み）
- **ギア比**: 54.78:1（実測値、ファームウェアに組み込み済み）
- **車輪円周**: 212.06mm
- **変換係数**: 0.2564 mm/count

## ディレクトリ構成

```
MobileRobot/
├── edge_services/              # Python WebSocket サービス
│   ├── hardware/              # ハードウェアドライバ
│   │   ├── pr2040_usb_driver.py    # USB シリアルドライバ (使用中)
│   │   └── pr2040_driver.py        # I2C ドライバ (非推奨)
│   ├── config/                # 設定ファイル
│   │   └── robot_config.json  # ロボット設定
│   ├── motor_service.py       # モーター制御サービス (WS:8001)
│   ├── odometry_service.py    # オドメトリサービス (WS:8002)
│   ├── camera_service.py      # カメラサービス (WS:8003)
│   └── launch_all.py          # 全サービス起動スクリプト
│
├── ros2_docker/               # ROS 2 Docker 環境
│   ├── Dockerfile             # ROS 2 Jazzy イメージ
│   └── docker-compose.yml     # Docker Compose 設定
│
├── mobile_robot_edge/         # ROS 2 パッケージ
│   ├── mobile_robot_edge/
│   │   ├── ws_motor_controller.py      # /cmd_vel → WS ブリッジ
│   │   └── ws_odometry_publisher.py    # WS → /odom ブリッジ
│   ├── launch/
│   │   └── ws_edge_bringup.launch.py   # 起動ファイル
│   ├── urdf/
│   │   └── mobile_robot.urdf           # ロボットモデル
│   ├── package.xml
│   └── setup.py
│
├── MotorDriver/               # PR2040 ファームウェア
│   └── Firmware/
│       └── PR2040_MotorDriver/
│           ├── PR2040_MotorDriver.ino  # メインファームウェア
│           └── CommandReference.md     # 通信プロトコル仕様
│
├── docs/                      # ドキュメント
│   └── raspberry_pi_setup.md  # Raspberry Pi セットアップガイド
│
└── test_*.py                  # 各種テストスクリプト
```

## セットアップ

### クイックスタート

```bash
# 1. リポジトリのクローン
git clone https://github.com/rx178nwj/MobileRobot.git
cd MobileRobot

# 2. 詳細なセットアップ手順に従う
# docs/raspberry_pi_setup.md を参照してください
```

### 詳細なセットアップ

完全なセットアップ手順については、以下のドキュメントを参照してください:

📚 **[Raspberry Pi セットアップガイド](docs/raspberry_pi_setup.md)**

このガイドには以下が含まれます:
- システム要件
- Docker インストール
- Python 環境セットアップ
- ハードウェア接続確認
- Edge Services セットアップ
- ROS 2 Docker 環境セットアップ
- システムの起動方法
- トラブルシューティング

## 使い方

### システムの起動

#### 1. Edge Services の起動（ターミナル 1）

```bash
cd ~/MobileRobot/edge_services
python3 launch_all.py
```

#### 2. ROS 2 システムの起動（ターミナル 2）

```bash
cd ~/MobileRobot/ros2_docker
docker compose run --rm ros2 bash -c "
    source /opt/ros/jazzy/setup.bash && \
    source /home/pi/ros2_ws/install/setup.bash && \
    ros2 launch mobile_robot_edge ws_edge_bringup.launch.py
"
```

#### 3. ロボットの制御（ターミナル 3）

```bash
cd ~/MobileRobot/ros2_docker
docker compose run --rm ros2 bash

# コンテナ内で
source /opt/ros/jazzy/setup.bash
source /home/pi/ros2_ws/install/setup.bash

# 前進コマンド
ros2 topic pub --once /cmd_vel geometry_msgs/msg/Twist \
    "{linear: {x: 0.1, y: 0.0, z: 0.0}, angular: {x: 0.0, y: 0.0, z: 0.0}}"

# オドメトリの確認
ros2 topic echo /odom
```

### テスト

#### 総合テストスイート

```bash
cd ~/MobileRobot
python3 test_usb_services.py
```

#### モーター個別テスト

```bash
# 各モーターを個別にテスト（DIRECT モード）
python3 test_motors_complete.py --test direct

# 10cm 前進テスト（VELOCITY モード）
python3 test_motors_complete.py --test velocity
```

#### USB 通信テスト

```bash
# 基本的な USB 通信テスト
python3 test_pr2040_usb_fixed.py --test basic

# 10cm 移動テスト
python3 test_pr2040_usb_fixed.py --test move
```

## 通信プロトコル

### USB シリアルプロトコル

PR2040 との通信は以下のパケット形式を使用:

```
[0xAA][CMD][LEN][DATA...][CHECKSUM]
```

- **Header**: 0xAA（固定）
- **CMD**: コマンドバイト
- **LEN**: データ長
- **DATA**: コマンドデータ
- **CHECKSUM**: XOR チェックサム（CMD ^ LEN ^ DATA[0] ^ ... ^ DATA[LEN-1]）

詳細は [CommandReference.md](MotorDriver/Firmware/PR2040_MotorDriver/CommandReference.md) を参照。

### WebSocket プロトコル

#### モーター制御（ポート 8001）

```json
{
  "type": "cmd_vel",
  "linear": 0.1,    // m/s
  "angular": 0.5    // rad/s
}
```

#### オドメトリ（ポート 8002）

```json
{
  "type": "odom",
  "timestamp": 1234567.89,
  "pose": {
    "x": 0.0,       // meters
    "y": 0.0,       // meters
    "theta": 0.0    // radians
  },
  "twist": {
    "linear": 0.0,  // m/s
    "angular": 0.0  // rad/s
  },
  "encoders": [100, 100, 0, 0]
}
```

## 既知の問題

### ハードウェア

- **モーター 2 と 3**: ハードウェアの問題により動作しません（エンコーダ値が常に 0）
- **モーター 0 と 1**: 正常に動作します

### 対応予定

これらのハードウェア問題は、モータードライバボードまたは配線の問題と考えられます。

## 開発状況

### 完了

- ✅ PR2040 ファームウェア（USB シリアル + I2C）
- ✅ USB シリアルドライバ
- ✅ Edge Services（モーター制御、オドメトリ、カメラ）
- ✅ ROS 2 Docker 環境
- ✅ WebSocket ブリッジ
- ✅ 基本的な動作確認

### 今後の予定

- ⏳ IMU センサー統合
- ⏳ カメラ画像処理
- ⏳ ナビゲーションスタック（Nav2）
- ⏳ SLAM（地図作成と自己位置推定）
- ⏳ 自律ナビゲーション

## ライセンス

このプロジェクトは MIT ライセンスの下で公開されています。

## 貢献

プルリクエストを歓迎します。大きな変更の場合は、まず issue を開いて変更内容を議論してください。

## 作者

- GitHub: [@rx178nwj](https://github.com/rx178nwj)

## 謝辞

- ROS 2 コミュニティ
- Raspberry Pi Foundation
- Arduino/RP2040 コミュニティ

---

**最終更新日**: 2026-03-15

## KiCad design MotorDriver/PR2040_DC_MOTOR_DRIVER 1.5.0/PR2040_BASESYSTEM.kicad_pcb

Parts:
C2, C3: 27pF; C_0402_1005Metric
C5, C6, C7, C9, C11, C12, C13, C14, C15, C16: 100nF; C_0402_1005Metric
C8, C10: 1uF; C_0402_1005Metric
C17: 10uF; C_0805_2012Metric
C33, C40: 1uF; C_0805_2012Metric
C38, C39: 200uF35V; CP_Radial_D8.0mm_P3.50mm
D13: LED ERROR (RED); LED_0603_1608Metric
D14: LED STATUS 1 (GREEN); LED_0603_1608Metric
D15: LED STATUS 2 (YELLOW); LED_0603_1608Metric
H1, H2, H3, H4: MountingHole; MountingHole_2.7mm_M2.5
J1: USB_C_Receptacle; USB_C_Receptacle_Amphenol_12401610E4-2A
J3, J4, J5, J6: Conn_01x02_Male; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J11: Conn_01x03_Male; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J12, J16: Conn_01x03_Male; simpleconn
J13: Conn_01x02_Male; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
J14: Conn_01x04_Male; JST_PH_B4B-PH-K_1x04_P2.00mm_Vertical
J15: Conn_01x03_Male; PinHeader_1x03_P2.54mm_Vertical
JP1: Jumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
NT1: NetTie_2; NetTie-2_SMD_Pad0.5mm
R1, R5, R63, R64, R65: 1k; R_0402_1005Metric
R2: DNF; R_0402_1005Metric
R3, R4: 27; R_0402_1005Metric
R6: 5k; R_0402_1005Metric
R34: 20k; R_0402_1005Metric
R35: 10k; R_0402_1005Metric
R58, R59: 4.7k; R_0402_1005Metric
R60, R61: 4.7k; R_0603_1608Metric
SW1, SW2: SW_SKSG10; SW_SKSGACE010
U2: W25Q128JVPIQ TR; WSON-8-1EP_6x5mm_P1.27mm_EP3.4x4mm
U3: RP2040; RP2040-QFN-56
U20: NCP360; TSOP-5_1.65x3.05mm_P0.95mm
Y1: FA-238 12MHz; Crystal_SMD_SeikoEpson_FA238V-4Pin_3.2x2.5mm

Connections:
+1V1: C6.1, C7.1, C8.1, U3.23 (DVDD), U3.45 (VREG_VOUT), U3.50 (DVDD)
+BATT: C38.1, C39.1, J11.1, J13.1, R34.1; also elsewhere on the board
/AD_CH5: J12.1; also elsewhere on the board
/AD_CH6: J12.2; also elsewhere on the board
/AD_CH7: J12.3; also elsewhere on the board
/DC Motor Drive 1, 2ch/MOT1_OUT1: J3.1; also elsewhere on the board
/DC Motor Drive 1, 2ch/MOT1_OUT2: J3.2; also elsewhere on the board
/DC Motor Drive 1, 2ch/MOT2_OUT1: J4.1; also elsewhere on the board
/DC Motor Drive 1, 2ch/MOT2_OUT2: J4.2; also elsewhere on the board
/DC Motor Drive 1, 2ch/Mot_Vref1: JP1.2 (B); also elsewhere on the board
/DC Motor Drive 3, 4ch/MOT3_OUT1: J5.1; also elsewhere on the board
/DC Motor Drive 3, 4ch/MOT3_OUT2: J5.2; also elsewhere on the board
/DC Motor Drive 3, 4ch/MOT4_OUT1: J6.1; also elsewhere on the board
/DC Motor Drive 3, 4ch/MOT4_OUT2: J6.2; also elsewhere on the board
/GPIO0: U3.2 (GPIO0); also elsewhere on the board
/GPIO1: U3.3 (GPIO1); also elsewhere on the board
/GPIO8: U3.11 (GPIO8); also elsewhere on the board
/GPIO9: U3.12 (GPIO9); also elsewhere on the board
/GPIO10: U3.13 (GPIO10); also elsewhere on the board
/GPIO11: U3.14 (GPIO11); also elsewhere on the board
/GPIO14: U3.17 (GPIO14); also elsewhere on the board
/GPIO15: U3.18 (GPIO15); also elsewhere on the board
/GPIO16: U3.27 (GPIO16); also elsewhere on the board
/GPIO17: U3.28 (GPIO17); also elsewhere on the board
/GPIO18: U3.29 (GPIO18); also elsewhere on the board
/GPIO19: U3.30 (GPIO19); also elsewhere on the board
/GPIO20: U3.31 (GPIO20); also elsewhere on the board
/GPIO21: U3.32 (GPIO21); also elsewhere on the board
/GPIO22: U3.34 (GPIO22); also elsewhere on the board
/GPIO23: U3.35 (GPIO23); also elsewhere on the board
/GPIO24: U3.36 (GPIO24); also elsewhere on the board
/GPIO25: U3.37 (GPIO25); also elsewhere on the board
/GPIO26_ADC0: R34.2, R35.1, U3.38 (GPIO26_ADC0)
/GPIO27_ADC1: R65.2, U3.39 (GPIO27_ADC1)
/GPIO28_ADC2: R64.2, U3.40 (GPIO28_ADC2)
/GPIO29_ADC3: R63.2, U3.41 (GPIO29_ADC3)
/I2C0_SCL: R58.2, U3.16 (GPIO13); also elsewhere on the board
/I2C0_SDA: R59.2, U3.15 (GPIO12); also elsewhere on the board
/I2C_SCL: J14.1, R61.2, U3.5 (GPIO3)
/I2C_SDA: J14.2, R60.2, U3.4 (GPIO2)
/Mot_Vref2: JP1.1 (A); also elsewhere on the board
/QSPI_SCLK: U2.6 (CLK), U3.52 (QSPI_SCLK)
/QSPI_SD0: U2.5 (DI(IO0)), U3.53 (QSPI_SD0)
/QSPI_SD1: U2.2 (DO(IO1)), U3.55 (QSPI_SD1)
/QSPI_SD2: U2.3 (IO2), U3.54 (QSPI_SD2)
/QSPI_SD3: U2.7 (IO3), U3.51 (QSPI_SD3)
/QSPI_SS: R1.1, R2.2, U2.1 (~CS), U3.56 (QSPI_SS)
/RUN: J16.3, SW1.4 (A), U3.26 (RUN)
/SPI0_CLK: U3.8 (GPIO6); also elsewhere on the board
/SPI0_Cn: U3.7 (GPIO5); also elsewhere on the board
/SPI0_RX: U3.6 (GPIO4); also elsewhere on the board
/SPI0_TX: U3.9 (GPIO7); also elsewhere on the board
/SWCLK: J15.1, U3.24 (SWCLK)
/SWDIO: J15.3, U3.25 (SWD)
/USB_D+: J1.A6 (D+), J1.B6 (D+), R3.1
/USB_D-: J1.A7 (D-), J1.B7 (D-), R4.1
/XIN: C2.1, U3.20 (XIN), Y1.3
/XOUT: R5.1, U3.21 (XOUT)
/~USB_BOOT: J16.2, R1.2, SW2.4 (A)
GND: C2.2, C3.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C33.2, C40.2, D13.1 (K), D14.1 (K), D15.1 (K), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J14.4, J15.2, J16.1, NT1.1, R6.2, R35.2, SW1.1, SW1.3 (K), SW1.5 (GND), SW1.6 (GND), SW2.1, SW2.3 (K), SW2.5 (GND), SW2.6 (GND), U2.4 (GND), U3.19 (TESTEN), U3.57 (GND), U20.2 (GND), U20.3 (~EN), Y1.2, Y1.4; also elsewhere on the board
GNDPWR: C38.2, C39.2, J11.3, J13.2, NT1.2; also elsewhere on the board
unnamed: C3.1, R5.2, Y1.1
unnamed: C33.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), U20.1 (IN)
unnamed: D13.2 (A), R63.1
unnamed: D14.2 (A), R64.1
unnamed: D15.2 (A), R65.1
unnamed: J1.A5 (CC1), J1.B5 (CC2), R6.1
unnamed: R3.2, U3.47 (USB_DP)
unnamed: R4.2, U3.46 (USB_DM)
VBUS: C40.1, U20.5 (OUT); also elsewhere on the board

Notes on the sheet:
電源の分圧
I2Cのプルアップ
Reset SW
Make sure C10 is close to pin 44 of RP2040
Power
Crystal
USB Connector
IOs
Make sure C8 is close to pin 45 of RP2040
Flash
Make sure R3 and R4 are close to RP2040

Parts:
C1: 2.2uF; C_0805_2012Metric
C4, C18, C44: 0.1uF; C_0402_1005Metric
C22, C23, C26, C27: 10nF; C_0402_1005Metric
C41, C43, C50, C51, C52, C53, C60: 0.1uF; C_0805_2012Metric
C61: 0.1uF; C_0603_1608Metric
C69, C70: 2.2uF; C_0603_1608Metric
D1, D3: LED GREEN; LED_0603_1608Metric
D2, D4: LED YELLOW; LED_0603_1608Metric
R7: 100; R_0402_1005Metric
R8, R9, R10, R11: 1k; R_0402_1005Metric
R12, R13: 10m; R_1206_3216Metric
R21, R22, R25, R26: 16k; R_0402_1005Metric
R30: 20k; R_0402_1005Metric
R31: 10k; R_0402_1005Metric
U1: LM4040DBZ-3.0; SOT-23
U4, U6: TB67H451; HSOP-8-1EP_3.9x4.9mm_P1.27mm_EP2.41x3.1mm
U5, U7: INA21x_SC70; SOT-363_SC-70-6
U13: MCP602; SOP-8_3.9x4.9mm_P1.27mm
U21: MCP1792_SOT-23A; SOT-23

Connections:
+BATT: C60.2, C61.2, C69.1, U4.5 (VM), U6.5 (VM), U21.3 (Vin); also elsewhere on the board
/AD_CH0: C26.1, U13.1, U13.2 (-); also elsewhere on the board
/AD_CH1: C27.1, U13.6 (-), U13.7; also elsewhere on the board
/DC Motor Drive 1, 2ch/5V_Vref: C70.1, U4.4 (VREF), U6.4 (VREF), U21.2 (Vout)
/DC Motor Drive 1, 2ch/MOT1_CURR: R21.2, U7.6 (OUT)
/DC Motor Drive 1, 2ch/MOT1_OUT1: C51.2, C52.1, U6.6 (OUT1); also elsewhere on the board
/DC Motor Drive 1, 2ch/MOT1_OUT2: C52.2, C53.1, U6.8 (OUT2); also elsewhere on the board
/DC Motor Drive 1, 2ch/MOT2_CURR: R22.2, U5.6 (OUT)
/DC Motor Drive 1, 2ch/MOT2_OUT1: C41.2, C43.1, U4.6 (OUT1); also elsewhere on the board
/DC Motor Drive 1, 2ch/MOT2_OUT2: C43.2, C50.1, U4.8 (OUT2); also elsewhere on the board
/DC Motor Drive 1, 2ch/Mot1_Curr+: R13.1, U6.7 (RS), U7.4 (IN+)
/DC Motor Drive 1, 2ch/Mot2_Curr+: R12.1, U4.7 (RS), U5.4 (IN+)
/DC Motor Drive 1, 2ch/Mot_Vref1: R30.2, R31.1, U5.1 (Ref), U7.1 (Ref); also elsewhere on the board
/GPIO8: R8.2, U6.3 (IN1); also elsewhere on the board
/GPIO9: R9.2, U6.2 (IN2); also elsewhere on the board
/GPIO10: R10.2, U4.3 (IN1); also elsewhere on the board
/GPIO11: R11.2, U4.2 (IN2); also elsewhere on the board
GND: C1.2, C4.2, C18.2, C22.2, C23.2, C44.1, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), R31.2, U1.2 (A), U5.2 (GND), U7.2 (GND), U13.4 (V-); also elsewhere on the board
GNDPWR: C41.1, C50.2, C51.1, C53.2, C60.1, C61.1, C69.2, C70.2, R12.2, R13.2, U4.1 (GND), U4.9 (E_PAD), U5.5 (IN-), U6.1 (GND), U6.9 (E_PAD), U7.5 (IN-), U21.1 (GND); also elsewhere on the board
unnamed: C1.1, R7.1, R30.1, U1.1 (K)
unnamed: C22.1, R25.1, U13.3 (+)
unnamed: C23.1, R26.1, U13.5 (+)
unnamed: C26.2, R21.1, R25.2
unnamed: C27.2, R22.1, R26.2
unnamed: D1.2 (A), R8.1
unnamed: D2.2 (A), R9.1
unnamed: D3.2 (A), R10.1
unnamed: D4.2 (A), R11.1

Notes on the sheet:
Imax:+-5V Vout:5V Gain:100 = 5m
LPF 1kHz R1,R2 = 33kΩ C1,C2 = 0.01uF LPF 1kHz R1,R2 = 16kΩ C1,C2 = 0.01uF LPF 2kHz R1,R2 = 8.2kΩ C1,C2 = 0.01uF
V Imax(A) R Gain IC 2 8 5m 100 INA214 1.5 5 3m 100 INA214 2 4 10m 50 INA213
1.0V

Parts:
C19: 2.2uF; C_0805_2012Metric
C20, C21, C49: 0.1uF; C_0402_1005Metric
C45, C46, C47, C48: 10nF; C_0402_1005Metric
C54, C55, C56, C57, C58, C59, C63: 0.1uF; C_0805_2012Metric
C62: 0.1uF; C_0603_1608Metric
C71, C72: 2.2uF; C_0603_1608Metric
D5, D7: LED GREEN; LED_0603_1608Metric
D6, D8: LED YELLOW; LED_0603_1608Metric
R14: 750; R_0402_1005Metric
R15, R16, R17, R18: 1k; R_0402_1005Metric
R19, R20: 10m; R_1206_3216Metric
R32: 20k +-0.5%; R_0402_1005Metric
R33: 10k +-0.5%; R_0402_1005Metric
R37, R38, R39, R40: 16k; R_0402_1005Metric
U8: LM4040DBZ-3.0; SOT-23
U9, U11: TB67H451; HSOP-8-1EP_3.9x4.9mm_P1.27mm_EP2.41x3.1mm
U10, U12: INA21x_SC70; SOT-363_SC-70-6
U18: MCP602; SOIC-8_3.9x4.9mm_P1.27mm
U23: MCP1792_SOT-23A; SOT-23

Connections:
+BATT: C62.2, C63.2, C71.1, U9.5 (VM), U11.5 (VM), U23.3 (Vin); also elsewhere on the board
/AD_CH2: C47.1, U18.1, U18.2 (-); also elsewhere on the board
/AD_CH3: C48.1, U18.6 (-), U18.7; also elsewhere on the board
/DC Motor Drive 3, 4ch/5V_Vref: C72.1, U9.4 (VREF), U11.4 (VREF), U23.2 (Vout)
/DC Motor Drive 3, 4ch/MOT3_CURR: R37.2, U12.6 (OUT)
/DC Motor Drive 3, 4ch/MOT3_OUT1: C57.2, C58.1, U11.6 (OUT1); also elsewhere on the board
/DC Motor Drive 3, 4ch/MOT3_OUT2: C58.2, C59.1, U11.8 (OUT2); also elsewhere on the board
/DC Motor Drive 3, 4ch/MOT4_CURR: R38.2, U10.6 (OUT)
/DC Motor Drive 3, 4ch/MOT4_OUT1: C54.2, C55.1, U9.6 (OUT1); also elsewhere on the board
/DC Motor Drive 3, 4ch/MOT4_OUT2: C55.2, C56.1, U9.8 (OUT2); also elsewhere on the board
/DC Motor Drive 3, 4ch/Mot3_Curr+: R20.1, U11.7 (RS), U12.4 (IN+)
/DC Motor Drive 3, 4ch/Mot4_Curr+: R19.1, U9.7 (RS), U10.4 (IN+)
/GPIO14: R15.2, U11.3 (IN1); also elsewhere on the board
/GPIO15: R16.2, U11.2 (IN2); also elsewhere on the board
/GPIO16: R17.2, U9.3 (IN1); also elsewhere on the board
/GPIO17: R18.2, U9.2 (IN2); also elsewhere on the board
/Mot_Vref2: R32.2, R33.1, U10.1 (Ref), U12.1 (Ref); also elsewhere on the board
GND: C19.2, C20.2, C21.2, C45.2, C46.2, C49.1, D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), R33.2, U8.2 (A), U10.2 (GND), U12.2 (GND), U18.4 (V-); also elsewhere on the board
GNDPWR: C54.1, C56.2, C57.1, C59.2, C62.1, C63.1, C71.2, C72.2, R19.2, R20.2, U9.1 (GND), U9.9 (E_PAD), U10.5 (IN-), U11.1 (GND), U11.9 (E_PAD), U12.5 (IN-), U23.1 (GND); also elsewhere on the board
unnamed: C19.1, R14.1, R32.1, U8.1 (K)
unnamed: C45.1, R39.1, U18.3 (+)
unnamed: C46.1, R40.1, U18.5 (+)
unnamed: C47.2, R37.1, R39.2
unnamed: C48.2, R38.1, R40.2
unnamed: D5.2 (A), R15.1
unnamed: D6.2 (A), R16.1
unnamed: D7.2 (A), R17.1
unnamed: D8.2 (A), R18.1

Notes on the sheet:
Imax:+-5V Vout:5V Gain:100 = 5m
V Imax(A) R Gain IC 2 8 5m 100 INA214 1.5 5 3m 100 INA214 2 4 10m 50 INA213
1.0V
LPF 500Hz R1,R2 = 33kΩ C1,C2 = 0.01uF LPF 1kHz R1,R2 = 16kΩ C1,C2 = 0.01uF LPF 2kHz R1,R2 = 8.2kΩ C1,C2 = 0.01uF

Parts:
C29: 10uF; C_0805_2012Metric
C31, C34: 1uF; C_0805_2012Metric
C68: 100u; CP_Radial_D5.0mm_P2.50mm
C73: 0.1uF; C_0603_1608Metric
D9: SR54F
D12: LED BLUE; LED_0603_1608Metric
Q1: DMG3415; SOT-23
R29: 10k; R_0402_1005Metric
R62: 1k; R_0402_1005Metric
U15: NCP1117-3.3_SOT223; SOT-223-3_TabPin2

Connections:
+BATT: Q1.3 (D); also elsewhere on the board
GND: C29.2, C31.2, C34.2, C68.2, C73.2, D12.1 (K), R29.1, U15.1 (GND); also elsewhere on the board
unnamed: C31.1, C68.1, D9.1 (K), Q1.2 (S), U15.3 (VI)
unnamed: D12.2 (A), R62.1
VBUS: D9.2 (A), Q1.1 (G), R29.2; also elsewhere on the board

Parts:
C28: 10uF; C_0805_2012Metric
C32: 1u; C_0805_2012Metric
D11: LED Orange; LED_0603_1608Metric
J7: Conn_01x02_Male; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
Q2: SSM3J332R(6A)/DMG3415U(4A); SOT-23
Q3: 2SC2712; SOT-23
R53: 1k; R_0402_1005Metric
R56: 1.5k; R_0402_1005Metric
R71: 10k; R_0402_1005Metric
R72: 100k; R_0603_1608Metric
R73: 10k; R_0603_1608Metric
R74: 3.3k; R_0603_1608Metric
R75: 100k; R_0402_1005Metric
R76: 160; R_0603_1608Metric
U17: MCP73213; DFN-10-1EP_3x3mm_P0.5mm_EP1.55x2.48mm

Connections:
+12V: C28.1, Q2.3 (D), U17.1 (VDD), U17.2 (VDD)
+BATT: U17.3 (VBAT), U17.4 (VBAT); also elsewhere on the board
/AD_CH4: C32.1, R76.1; also elsewhere on the board
/GPIO1: R71.1, R74.1; also elsewhere on the board
CHG_IN: J7.1, Q2.2 (S), R72.1, R75.1
GND: C32.2, R71.2; also elsewhere on the board
GNDPWR: C28.2, J7.2, Q3.2 (E), R56.1, R73.2, U17.8 (VSS), U17.9 (VSS), U17.11 (EP); also elsewhere on the board
unnamed: D11.1 (K), R53.1
unnamed: Q2.1 (G), Q3.3 (C), R75.2
unnamed: Q3.1 (B), R74.2
unnamed: R53.2, U17.7 (STAT)
unnamed: R56.2, U17.10 (PROG)
unnamed: R72.2, R73.1, R76.2

Parts:
C30: 0.1uF; C_0402_1005Metric
U19: S-5851A; SOT-23-6

Connections:
/I2C0_SCL: U19.1 (SCL); also elsewhere on the board
/I2C0_SDA: U19.6 (SDA); also elsewhere on the board
GND: C30.2, U19.2 (VSS), U19.3 (AD1), U19.5 (AD0); also elsewhere on the board

Parts:
C35, C36: 0.1uF; C_0402_1005Metric
C37: 10nF; C_0402_1005Metric
U16: MPU-6881; QFN-24-1EP_3x3mm_P0.4mm_EP1.75x1.6mm

Connections:
/GPIO0: U16.12 (INT); also elsewhere on the board
/I2C0_SCL: U16.23 (SCL/SCLK); also elsewhere on the board
/I2C0_SDA: U16.24 (SDA/SDI); also elsewhere on the board
GND: C35.2, C36.2, C37.2, U16.9 (SDO/ADD), U16.11 (FSYNC), U16.18 (GND), U16.20 (RESV); also elsewhere on the board
unnamed: C36.1, U16.10 (REGOUT)
